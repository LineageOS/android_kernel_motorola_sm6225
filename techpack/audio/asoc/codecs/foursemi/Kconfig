## techpack/audio/asoc/codecs/foursemi/Kconfig
```kconfig
config SND_SOC_FS16XX
       tristate "Support foursemi fs16xx chip"
	   depends on I2C
	   help
	   foursemi fs16xx driver
```
